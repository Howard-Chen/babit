// 英文跑馬燈
// @desc 3×5 點陣字由右往左捲動；旋鈕調速度、按鈕 1 換文字、按鈕 2 換顏色
// 旋鈕：捲動速度（中間＝每秒 10 欄；轉到最左也還在慢慢捲）
// 按鈕 1：換下一句（TEXTS 裡的句子輪流，換了從右邊重新進場）
// 按鈕 2：換顏色（彩虹隨字 → 紅 → 黃 → 綠 → 藍 → 白）
// 字型是自己畫的：每個字 5 排、每排 3 格，'#' 亮、'.' 暗。有 A–Z、0–9、空白和 ! ? . , - :，小寫自動當大寫。
// 捲動的做法：把整句話攤成一長條「欄」，畫面是 WIDTH 欄寬的窗戶，隨時間往右滑。
#define PANEL 8
#include "BatoPixel.h"

const char* const TEXTS[] = {"HELLO", "BABIT"};          // 要捲動的句子：想加幾句就加幾句，例如自己的名字
const int COUNT = sizeof(TEXTS) / sizeof(TEXTS[0]);      // 有幾句
const Color COLORS[] = {RED, YELLOW, GREEN, BLUE, WHITE};    // 按鈕 2 的單色（彩虹隨字之後依序換）
const int TOP = 1;                  // 字從第幾排開始畫：5 排高放第 1–5 排，看起來最像置中

struct Glyph {
  char ch;
  const char* rows[5];
};

const Glyph FONT[] = {
  {'A', {".#.", "#.#", "###", "#.#", "#.#"}}, {'B', {"##.", "#.#", "##.", "#.#", "##."}},
  {'C', {".##", "#..", "#..", "#..", ".##"}}, {'D', {"##.", "#.#", "#.#", "#.#", "##."}},
  {'E', {"###", "#..", "##.", "#..", "###"}}, {'F', {"###", "#..", "##.", "#..", "#.."}},
  {'G', {".##", "#..", "#.#", "#.#", ".##"}}, {'H', {"#.#", "#.#", "###", "#.#", "#.#"}},
  {'I', {"###", ".#.", ".#.", ".#.", "###"}}, {'J', {"..#", "..#", "..#", "#.#", ".#."}},
  {'K', {"#.#", "#.#", "##.", "#.#", "#.#"}}, {'L', {"#..", "#..", "#..", "#..", "###"}},
  {'M', {"#.#", "###", "###", "#.#", "#.#"}}, {'N', {"##.", "#.#", "#.#", "#.#", "#.#"}},
  {'O', {"###", "#.#", "#.#", "#.#", "###"}}, {'P', {"##.", "#.#", "##.", "#..", "#.."}},
  {'Q', {"###", "#.#", "#.#", "###", "..#"}}, {'R', {"##.", "#.#", "##.", "#.#", "#.#"}},
  {'S', {".##", "#..", ".#.", "..#", "##."}}, {'T', {"###", ".#.", ".#.", ".#.", ".#."}},
  {'U', {"#.#", "#.#", "#.#", "#.#", "###"}}, {'V', {"#.#", "#.#", "#.#", "#.#", ".#."}},
  {'W', {"#.#", "#.#", "###", "###", "#.#"}}, {'X', {"#.#", "#.#", ".#.", "#.#", "#.#"}},
  {'Y', {"#.#", "#.#", ".#.", ".#.", ".#."}}, {'Z', {"###", "..#", ".#.", "#..", "###"}},
  {'0', {".#.", "#.#", "#.#", "#.#", ".#."}}, {'1', {".#.", "##.", ".#.", ".#.", "###"}},
  {'2', {"##.", "..#", ".#.", "#..", "###"}}, {'3', {"##.", "..#", ".#.", "..#", "##."}},
  {'4', {"#.#", "#.#", "###", "..#", "..#"}}, {'5', {"###", "#..", "##.", "..#", "##."}},
  {'6', {".##", "#..", "###", "#.#", "###"}}, {'7', {"###", "..#", ".#.", ".#.", ".#."}},
  {'8', {"###", "#.#", "###", "#.#", "###"}}, {'9', {"###", "#.#", "###", "..#", "##."}},
  {'!', {".#.", ".#.", ".#.", "...", ".#."}}, {'?', {"##.", "..#", ".#.", "...", ".#."}},
  {'.', {"...", "...", "...", "...", ".#."}}, {',', {"...", "...", "...", ".#.", "#.."}},
  {'-', {"...", "...", "###", "...", "..."}}, {':', {"...", ".#.", "...", ".#.", "..."}},
};

// 在字型表裡找這個字（小寫當大寫）；找不到（例如空白）就當成空白
const Glyph* findGlyph(char ch) {
  if (ch >= 'a' && ch <= 'z') ch = ch - 'a' + 'A';
  for (const Glyph& g : FONT)
    if (g.ch == ch) return &g;
  return nullptr;
}

int which = 0;                      // 現在是第幾句
int colorMode = 0;                  // 0＝彩虹隨字，1 之後是 COLORS 裡的單色
float pos = 0;                      // 捲到第幾欄（有小數）：每格加上「速度 × 經過的秒數」，轉旋鈕時才不會跳
float lastT = 0;                    // 上一格的 seconds()

void setup() {
  begin();
}

void loop() {
  float t = seconds();
  float dt = t - lastT;             // 跟上一格差幾秒（大約 1/60）
  lastT = t;

  if (button1.clicked()) { which = (which + 1) % COUNT; pos = 0; }   // 按一下按鈕 1：換下一句，從右邊重新進場
  if (button2.clicked()) colorMode = (colorMode + 1) % 6;            // 按一下按鈕 2：換下一種顏色
  float speed = 10 * powf(3, knob.value() * 2 - 1);                  // 旋鈕：每秒捲幾欄（最左約 3、中間 10、最右 30）

  const char* msg = TEXTS[which];
  int len = 0;                      // 這句有幾個字
  while (msg[len]) len++;
  const int LEAD = WIDTH;           // 開頭空一整個畫面，字從右邊進場
  const int TOTAL = LEAD + len * 4; // 整條有幾欄：每個字 3 欄＋1 欄字距
  pos = fmodf(pos + speed * dt, TOTAL);
  int shift = (int)pos;             // 現在捲到第幾欄

  clear();
  for (int x = 0; x < WIDTH; x++) {
    int col = (shift + x) % TOTAL;        // 畫面第 x 欄＝整條的第幾欄
    if (col < LEAD) continue;             // 開頭的空白
    int n = (col - LEAD) / 4;             // 第幾個字
    int c = (col - LEAD) % 4;             // 字裡的第幾欄（第 3 欄是字距）
    const Glyph* g = findGlyph(msg[n]);
    if (c == 3 || g == nullptr) continue;

    Color color = colorMode == 0 ? hsv((col - LEAD) * 11, 255, 255)   // 彩虹隨字：越後面的字色相越大，紅 → 藍
                                 : COLORS[colorMode - 1];
    for (int y = 0; y < 5; y++)
      if (g->rows[y][c] == '#') dot(x, TOP + y, color);
  }
  show();
}
